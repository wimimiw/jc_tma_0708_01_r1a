# Keil uVision project rf_module.uvproj, settings and files
target Debug (ARM-ADS)
  device: STM32F101C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rf_module
  c define: STM32F10X_MD_VL,USE_STDPERIPH_DRIVER
  c include: ..\app;..\device;..\driver\inc;..\driver;..\cpu
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\debug\output\rf_module.sct
  link misc: --keep rf_control.o(POINTER) --keep rf_control.o(.text) --keep user_flash.o(BOOTLOADER)  --keep stm32f10x_flash.o(.text) --keep stm32f10x_iwdg.o(.text)
  group app
    ../app/: main.c rf_control.c rf_protocol.c rf_parameter.c task.c target.c stm32f10x_it.c system_stm32f10x.c
  group device
    ../device/: dev_spi.c dev_att.c dev_e2prom.c dev_temp.c
  group driver
    ../driver/: user_timer.c user_adc.c user_i2c.c user_uart.c user_flash.c
    ../driver/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c
  group cpu
    ../cpu/: core_cm3.c startup_stm32f10x_md_vl.s
target Release (ARM-ADS)
  device: STM32F101C8 STMicroelectronics
  cpu: as above
  output: rf_module +hex
  AfterMake: .\outConv.exe release/output/@L.hex ../release/jctma-0708-01-r1a 0x0000 0x7000  0x5ff0
  c define: STM32F10X_MD_VL,USE_STDPERIPH_DRIVER,WATCHDOG_EN
  c include: ..\app;..\device;..\driver\inc;..\driver;..\cpu
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\release\output\rf_module.sct
  link misc: as above
